# Keil uVision project F107.uvproj, settings and files
target STM32F107 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: F107
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\..\libs\os\include;..\..\libs\os\include\os\arch\cortex_m3;..\..\compiler\armcc;..\..\libs\list\include;..\..\libs\baselibc\include;..\..\hw\bsp\shenzhou\include;..\..\hw\mcu\stm\stm32f1xx\include;..\..\libs\cmsis-core\include;..\timer_test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group apps/timer_test
    ./applications/: application.c io.c main.c timer_test.c
  group libs/os
    ../../libs/os/src/: os.c os_console.c os_error.c os_event.c os_heap.c os_idle.c os_ipc.c os_irq.c os_list.c os_mbox.c os_misc.c os_mpool.c os_mqueue.c os_mutex.c os_sched.c os_sem.c os_task.c os_tick.c os_timer.c os_timer_task.c os_version.c
  group libs/os/arch/cortex_m3
    ../../libs/os/src/arch/cortex_m3/: cpuport.c context_rvds.S os_arch_arm.c
  group libs/baselibc
    ../../libs/baselibc/src/: rtstdio.c rtstring.c
  group hw/bsp/shenzhou
    ../../hw/bsp/shenzhou/src/: system_stm32f10x.c usart.c bsp.c
    ../../hw/bsp/shenzhou/src/arch/cortex_m3/: startup_stm32f10x_cl.s
  group hw/mcu/stm/stm32f10x
    ../../hw/mcu/stm/stm32f1xx/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
