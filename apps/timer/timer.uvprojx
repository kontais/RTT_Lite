# Keil uVision project timer.uvprojx, settings and files
target STM32F107VC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: timer
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\board\shenzhou\include;..\..\mcu\stm\stm32f1xx\include;..\..\compiler\armcc;..\..\lib\os\include;..\..\lib\os\include\arch\cortex_m3;..\..\lib\c\include;.\include;..\..\lib\cmsis-core\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group board\shenzhou
    ../../board/shenzhou/src/: board.c system_stm32f10x.c usart.c startup_stm32f10x_cl.s
  group mcu\stm32f1xx
    ../../mcu/stm/stm32f1xx/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group lib\os\cortex_m3
    ../../lib/os/src/arch/cortex_m3/: cpuport.c context_rvds.S
  group lib\os
    ../../lib/os/src/: os.c os_console.c os_error.c os_event.c os_heap.c os_idle.c os_ipc.c os_irq.c os_list.c os_mbox.c os_misc.c os_mpool.c os_mqueue.c os_mutex.c os_sched.c os_sem.c os_task.c os_tick.c os_timer.c os_timer_task.c os_version.c
  group lib\c
    ../../lib/c/src/: rtstdio.c rtstring.c
  group apps\timer
    ./src/: application.c io.c main.c timer_test.c
