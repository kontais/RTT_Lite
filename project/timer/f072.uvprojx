# Keil uVision project f072.uvprojx, settings and files
target stm32f072rb (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f072
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072
  c include: ..\..\lib\cmsis\include;..\..\mcu\stm32\stm32f0xx\inc;..\..\board\nucleo-f072rb\include;..\..\lib\os\include;..\..\toolchain\armcc;..\..\lib\os\include\arch\cortex_m0;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group mcu\stm32f0xx
    ../../mcu/stm32/stm32f0xx/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_misc.c
  group board\nucleo-f072rb
    ../../board/nucleo-f072rb/src/: startup_stm32f072.s system_stm32f0xx.c board.c fputc.c usart2.c
  group lib\os\cortex_m0
    ../../lib/os/src/arch/cortex_m0/: context_rvds.S cpuport.c
  group lib\os
    ../../lib/os/src/: os.c os_error.c os_event.c os_heap.c os_idle.c os_ipc.c os_irq.c os_list.c os_mbox.c os_misc.c os_mpool.c os_mqueue.c os_mutex.c os_sched.c os_sem.c os_task.c os_tick.c os_timer.c os_version.c
  group project/timer
    ./src/: application.c main.c timer_test.c
