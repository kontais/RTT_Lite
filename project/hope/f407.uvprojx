# Keil uVision project f407.uvprojx, settings and files
target STM32F407ZG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\..\board\hope\include;..\..\mcu\stm32\stm32f4xx\include;..\..\toolchain\armcc;..\..\lib\os\include;..\..\lib\os\include\arch\cortex_m4;..\..\lib\c\include;..\..\lib\cmsis\include;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group mcu\stm32f4xx
    ../../mcu/stm32/stm32f4xx/src/: startup_stm32f40xx.s stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c system_stm32f4xx.c
  group board\hope
    ../../board/hope/src/: board.c led.c uart1.c fgetc.c fputc.c
  group lib\os\cortex_m4
    ../../lib/os/src/arch/cortex_m4/: cpuport.c context_rvds.S
  group lib\os
    ../../lib/os/src/: os.c os_error.c os_event.c os_heap.c os_idle.c os_ipc.c os_irq.c os_list.c os_mbox.c os_misc.c os_mpool.c os_mqueue.c os_mutex.c os_sched.c os_sem.c os_task.c os_tick.c os_timer.c os_version.c
  group project\timer
    ./src/: application.c main.c timer_test.c
